# Repository aliaksei-lameyka/ENKU-Base-reader (continued)

## KiCad design hardware/mainboard/kicad/enku-mainboard-r1.1-base-gated-battery-adc.kicad_pcb (continued)

Board: 4 copper layers, 123 parts (19 on the bottom side), 76 nets, no tracks yet.

Other parts of the board:
C37: 100nF 10V; C_0603_1608Metric
H1, H2, H3, H4: MountingHole_2.2mm_M2
R39: 1M; R_0603_1608Metric
U9: TMUX1101DBVR; SOT-23-5

Their connections:
3V3_SYS: R39.1, U9.4; also elsewhere on the board
BAT_ADC_SW: U9.1; also elsewhere on the board
GND: C37.2, R39.2, U9.3; also elsewhere on the board
VBAT: C37.1, U9.2, U9.5; also elsewhere on the board

File hardware/mainboard/kicad/checks/assembly_review_BOM_R129.csv (part):

Reference,Value,Manufacturer,MPN,Assembly,Footprint,Side,BoardX_mm,BoardY_mm,NativeCPL_X_mm,NativeCPL_Y_mm,Rotation_deg,MPN_field_status
C10,100nF,Yageo,CC0603KRX7R9BB104,FIT,ENKU:C_CC0603_YAGEO_REFLOW_TRANSFER,front,63.0,86.5,63.0,-86.5,0.0,EXPLICIT
C11,22uF 10V,Yageo,CC0805MKX5R6BB226,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,60.1,94.4,60.1,-94.4,0.0,EXPLICIT
C12,22uF 10V,Yageo,CC0805MKX5R6BB226,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,63.125,94.4,63.125,-94.4,0.0,EXPLICIT
C13,10uF 10V,Yageo,CC0805KKX5R6BB106,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,30.0,59.0,30.0,-59.0,0.0,EXPLICIT
C14,100nF,Yageo,CC0603KRX7R9BB104,FIT,ENKU:C_CC0603_YAGEO_REFLOW_TRANSFER,front,30.0,56.0,30.0,-56.0,0.0,EXPLICIT
C15,1uF,Yageo,CC0603KRX7R8BB105,FIT,ENKU:C_CC0603_YAGEO_REFLOW_TRANSFER,front,34.0,58.0,34.0,-58.0,0.0,EXPLICIT
C16,10uF 10V,Yageo,CC0805KKX5R6BB106,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,39.0,96.0,39.0,-96.0,90.0,EXPLICIT
C17,100nF,Yageo,CC0603KRX7R9BB104,FIT,ENKU:C_CC0603_YAGEO_REFLOW_TRANSFER,front,42.0,96.0,42.0,-96.0,90.0,EXPLICIT
C18,100nF,Yageo,CC0603KRX7R9BB104,FIT,ENKU:C_CC0603_YAGEO_REFLOW_TRANSFER,front,22.0,77.4,22.0,-77.4,90.0,EXPLICIT
C19,100nF,Yageo,CC0603KRX7R9BB104,FIT,ENKU:C_CC0603_YAGEO_REFLOW_TRANSFER,front,24.0,80.0,24.0,-80.0,90.0,EXPLICIT
C2,1uF 10V,Yageo,CC0805KKX7R6BB105,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,36.5,91.85,36.5,-91.85,0.0,EXPLICIT
C21,100nF,Yageo,CC0603KRX7R9BB104,FIT,ENKU:C_CC0603_YAGEO_REFLOW_TRANSFER,front,30.0,87.5,30.0,-87.5,90.0,EXPLICIT
C22,1uF 25V,Yageo,CC0603KRX7R8BB105,FIT,ENKU:C_CC0603_YAGEO_REFLOW_TRANSFER,front,46.2,27.0,46.2,-27.0,90.0,EXPLICIT
C23,1uF 25V,Yageo,CC0603KRX7R8BB105,FIT,ENKU:C_CC0603_YAGEO_REFLOW_TRANSFER,front,48.4,27.0,48.4,-27.0,90.0,EXPLICIT
C24,4.7uF 25V,Yageo,CC0805KKX7R8BB475,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,47.3,42.0,47.3,-42.0,90.0,EXPLICIT
C25,4.7uF 25V,Yageo,CC0805KKX7R8BB475,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,58.0,52.0,58.0,-52.0,0.0,EXPLICIT
C26,4.7uF 25V,Yageo,CC0805KKX7R8BB475,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,52.5,45.5,52.5,-45.5,90.0,EXPLICIT
C27,4.7uF 25V,Yageo,CC0805KKX7R8BB475,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,49.0,34.0,49.0,-34.0,90.0,EXPLICIT
C28,4.7uF 25V,Yageo,CC0805KKX7R8BB475,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,73.12,28.5,73.12,-28.5,90.0,EXPLICIT
C29,4.7uF 25V,Yageo,CC0805KKX7R8BB475,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,64.0,39.0,64.0,-39.0,90.0,EXPLICIT
C30,1uF 25V X7R,Yageo,CC0805KKX7R8BB105,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,66.0,39.0,66.0,-39.0,90.0,EXPLICIT
C31,4.7uF 25V,Yageo,CC0805KKX7R8BB475,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,53.0,43.0,53.0,-43.0,180.0,EXPLICIT
C35,4.7nF,Yageo,CC0603KRX7R9BB472,FIT,ENKU:C_CC0603_YAGEO_REFLOW_TRANSFER,front,66.0,108.5,66.0,-108.5,0.0,EXPLICIT
C37,100nF 10V,Yageo,CC0603KRX7R9BB104,FIT,ENKU:C_CC0603_YAGEO_REFLOW_TRANSFER,front,38.5,67.0,38.5,-67.0,0.0,EXPLICIT
C38,100nF 10V,Yageo,CC0603KRX7R9BB104,FIT,ENKU:C_CC0603_YAGEO_REFLOW_TRANSFER,front,60.0,65.0,60.0,-65.0,0.0,EXPLICIT
C39,1nF C0G 10V,Yageo,CC0603JRNPO9BN102,FIT,ENKU:C_CC0603_YAGEO_REFLOW_TRANSFER,front,66.0,76.0,66.0,-76.0,0.0,EXPLICIT
C4,1uF 25V,Yageo,CC0805KKX7R8BB105,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,43.8,86.8,43.8,-86.8,0.0,EXPLICIT
C5,4.7uF 25V,Yageo,CC0805KKX7R8BB475,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,45.5,88.5,45.5,-88.5,0.0,EXPLICIT
C6,100nF 25V,Yageo,CC0603KRX7R9BB104,FIT,ENKU:C_CC0603_YAGEO_REFLOW_TRANSFER,front,45.5,93.0,45.5,-93.0,0.0,EXPLICIT
C7,10uF 25V,Yageo,CC0805KKX5R8BB106,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,51.6,93.5,51.6,-93.5,90.0,EXPLICIT
C8,4.7uF 10V,Yageo,CC0805KKX5R6BB475,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,48.5,93.6,48.5,-93.6,180.0,EXPLICIT
C9,10uF 10V,Yageo,CC0805KKX5R6BB106,FIT,ENKU:C_CC0805_YAGEO_REFLOW_TRANSFER,front,59.7,87.7,59.7,-87.7,0.0,EXPLICIT
D1,MBR0530T1G,onsemi,MBR0530T1G,FIT,ENKU:MBR0530T1G_ONSEMI_CASE425H,front,49.25,44.0,49.25,-44.0,-90.0,EXPLICIT
D2,MBR0530T1G,onsemi,MBR0530T1G,FIT,ENKU:MBR0530T1G_ONSEMI_CASE425H,front,56.0,50.0,56.0,-50.0,180.0,EXPLICIT
D3,MBR0530T1G,onsemi,MBR0530T1G,FIT,ENKU:MBR0530T1G_ONSEMI_CASE425H,front,52.0,48.0,52.0,-48.0,180.0,EXPLICIT
H1,,,,BARE_PCB,ENKU:MOUNT_HOLE_D2_2_BOARD_ONLY,front,29.0,22.5,,,0.0,NOT_AN_ASSEMBLED_PART
H2,,,,BARE_PCB,ENKU:MOUNT_HOLE_D2_2_BOARD_ONLY,front,57.5,25.0,,,0.0,NOT_AN_ASSEMBLED_PART
H3,,,,BARE_PCB,ENKU:MOUNT_HOLE_D2_2_BOARD_ONLY,front,23.0,116.5,,,0.0,NOT_AN_ASSEMBLED_PART
H4,,,,BARE_PCB,ENKU:MOUNT_HOLE_D2_2_BOARD_ONLY,front,72.0,116.5,,,0.0,NOT_AN_ASSEMBLED_PART
J1,1S LiPo + NTC,,,FIT,ENKU:JST_PH_S3B-PH-SM4-TB_1x03-1MP_P2.00mm_Horizontal,front,69.8,93.5,69.8,-93.5,90.0,FIELD_FREEZE_PENDING
J2,Hirose DM3AT-SF-PEJM5,,,FIT,ENKU:MICROSD_DM3AT_ENKU,front,27.0,100.7,27.0,-100.7,-90.0,FIELD_FREEZE_PENDING
J3,FH34SRJ-24S-0.5SH(50),Hirose,FH34SRJ-24S-0.5SH(50),FIT,ENKU:FH34SRJ-24S-0.5SH,front,69.27,34.0,69.27,-34.0,0.0,EXPLICIT
J5,GCT USB4105-GF-A-120,,,FIT,ENKU:USB4105_EXISTING_LANDS_SHIELD_S,front,47.0,117.325,47.0,-117.325,0.0,FIELD_FREEZE_PENDING
J7,Tag-Connect TC2030-IDC-NL,,,BARE_PCB,ENKU:TC2030_NL_CONTACTS_PIN1,back,35.0,87.0,,,0.0,NOT_AN_ASSEMBLED_PART
L1,0.47uH DFE201612E-R47M=P2,,,FIT,ENKU:Murata_DFE201612E,front,61.2,91.0,61.2,-91.0,-90.0,FIELD_FREEZE_PENDING
L2,47uH TYS5040470M-10,,,FIT,ENKU:TYS5040_5x5,front,58.0,43.0,58.0,-43.0,0.0,FIELD_FREEZE_PENDING
Q1,IRLML6346TRPBF,,,FIT,ENKU:IRLML6346_INFINEON_MICRO3,front,67.0,48.0,67.0,-48.0,0.0,FIELD_FREEZE_PENDING
Q2,AO3401A,,,FIT,ENKU:AO3401A_AOS_SOT23,front,55.5,82.5,55.5,-82.5,0.0,FIELD_FREEZE_PENDING
R10,100k,Yageo,RC0603FR-07100KL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,51.8,89.4,51.8,-89.4,0.0,EXPLICIT
R11,10k,Yageo,RC0603FR-0710KL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,53.2,91.4,53.2,-91.4,90.0,EXPLICIT
R12,10k DNP,Yageo,RC0603FR-0710KL,DNP,ENKU:R_RC0603_YAGEO_REFLOW,front,53.3,94.2,,,90.0,EXPLICIT
R13,100k,Yageo,RC0603FR-07100KL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,69.0,85.3,69.0,-85.3,90.0,EXPLICIT
R14,511k 1%,Yageo,RC0603FR-07511KL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,55.3,88.3,55.3,-88.3,90.0,EXPLICIT
R15,91k 1%,Yageo,RC0603FR-0791KL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,53.9,88.3,53.9,-88.3,90.0,EXPLICIT
R16,100k,Yageo,RC0603FR-07100KL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,55.45,95.5,55.45,-95.5,0.0,EXPLICIT
R17,10k,Yageo,RC0603FR-0710KL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,34.0,56.0,34.0,-56.0,0.0,EXPLICIT
R18,10k,Yageo,RC0603FR-0710KL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,34.0,61.0,34.0,-61.0,0.0,EXPLICIT
R19,0R,Yageo,RC0603JR-070RL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,38.0,101.0,38.0,-101.0,0.0,EXPLICIT
R20,0R (22R tune),Yageo,RC0603JR-070RL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,38.0,104.0,38.0,-104.0,0.0,EXPLICIT
R21,0R (22R tune),Yageo,RC0603JR-070RL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,38.0,107.0,38.0,-107.0,0.0,EXPLICIT
R22,0R (22R tune),Yageo,RC0603JR-070RL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,30.0,110.0,30.0,-110.0,0.0,EXPLICIT
R23,47k,Yageo,RC0603FR-0747KL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,39.5,98.8,39.5,-98.8,0.0,EXPLICIT
R24,4.7k,Yageo,RC0603FR-074K7L,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,26.0,76.5,26.0,-76.5,90.0,EXPLICIT
R25,4.7k,Yageo,RC0603FR-074K7L,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,26.0,73.0,26.0,-73.0,90.0,EXPLICIT
R26,2M 1%,Yageo,RC0603FR-072ML,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,28.0,86.0,28.0,-86.0,90.0,EXPLICIT
R27,680k 1%,Yageo,RC0603FR-07680KL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,28.0,89.0,28.0,-89.0,90.0,EXPLICIT
R28,0R,Yageo,RC0603JR-070RL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,63.0,48.0,63.0,-48.0,0.0,EXPLICIT
R29,0R,Yageo,RC0603JR-070RL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,42.0,30.0,42.0,-30.0,90.0,EXPLICIT
R30,22R,Yageo,RC0603FR-0722RL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,42.0,27.0,42.0,-27.0,90.0,EXPLICIT
R31,22R,Yageo,RC0603FR-0722RL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,40.0,27.0,40.0,-27.0,90.0,EXPLICIT
R32,22R,Yageo,RC0603FR-0722RL,FIT,ENKU:R_RC0603_YAGEO_REFLOW,front,38.0,27.0,38.0,-27.0,90.0,EXPLICIT
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